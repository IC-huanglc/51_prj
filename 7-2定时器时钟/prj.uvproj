# Keil uVision project prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: prj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delay1ms.c Delay10us.c LCD1602.c Delay1ms.h Delay10us.h LCD1602.h Timer0.c Timer0.h
